# Autodesk Inventor assembly: Standard (mm)
## iProperties
Created: 2007-07
Part Number: Standard (mm)
Document SubType Name: Assembly
Designer: david.appleford
Author: david.appleford
